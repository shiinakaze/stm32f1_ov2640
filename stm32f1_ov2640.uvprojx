# Keil uVision project stm32f1_ov2640.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_ov2640 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\app;.\boards\bluepill;.\arch\arm\cortex-m3;.\chip\stm32f103;.\chip\stm32f103\system;.\chip\stm32f103\startup;.\chip\stm32f103\spl;.\chip\stm32f103\spl\inc;.\drivers\peripheral\uart;.\drivers\peripheral\i2c;.\drivers\device\camera\sccb;.\drivers\peripheral\timer;.\drivers\device\camera\sensor\ov2640;.\drivers\device\display\ssd1306;.\drivers\device\sensor\sht30;.\middleware\usb\inc;.\middleware\usb\uvc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: app_main.c app.h
  group boards/bluepill
    ./boards/bluepill/: board_config.h
  group arch/arm/cortex-m3
    ./arch/arm/cortex-m3/: core_cm3.c
  group chip/stm32f103
    ./chip/stm32f103/system/: system_stm32f10x.c
    ./chip/stm32f103/startup/: startup_stm32f10x_md.s
  group chip/stm32f103/spl
    ./chip/stm32f103/spl/: stm32f10x_conf.h
    ./chip/stm32f103/spl/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group kernel/baremetal
    ./kernel/baremetal/: main.c
  group drivers/peripheral/uart
    ./drivers/peripheral/uart/: uart.c
  group drivers/peripheral/i2c
    ./drivers/peripheral/i2c/: sw_i2c.c
  group drivers/peripheral/timer
    ./drivers/peripheral/timer/: timer.c
  group drivers/device/camera
    ./drivers/device/camera/sensor/ov2640/: ov2640.c ov2640_config.c
    ./drivers/device/camera/sccb/: sccb.c
  group drivers/device/display
    ./drivers/device/display/ssd1306/: ssd1306.c ssd1306_font.c
  group drivers/device/sensor
    ./drivers/device/sensor/sht30/: sht30.c
  group middleware/usb
    ./middleware/usb/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group middleware/usb/uvc
    ./middleware/usb/uvc/: usb_desc.c usb_prop.c usb_pwr.c usb_istr.c usb_bsp.c usbd_uvc.c
