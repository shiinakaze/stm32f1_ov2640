# Keil uVision project Project.uvprojx, settings and files
target STM32303xE_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303xE_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE,USE_STM32303C_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F30x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F30x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM32303C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group STM32F30x/STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_adc.c stm32f30x_dma.c stm32f30x_can.c stm32f30x_rcc.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_pwr.c stm32f30x_syscfg.c stm32f30x_misc.c stm32f30x_i2c.c stm32f30x_spi.c stm32f30x_usart.c
  group User
    ../src/: stm32_it.c usb_prop.c usb_endp.c hw_config.c usb_desc.c main.c usb_pwr.c usb_istr.c
  group Doc
    ../: readme.txt
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_int.c usb_mem.c usb_sil.c usb_init.c usb_regs.c
  group STM32F30x/CMSIS
    ./: startup_stm32f302x8.s startup_stm32f303xe.s
    ../src/: system_stm32f30x.c
  group STM32F30x/STM32303C_EVAL
    ../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
target STM32F302x8_Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F302x8_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8,USE_NUCLEO
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F30x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F30x_StdPeriph_Driver/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.3.0
