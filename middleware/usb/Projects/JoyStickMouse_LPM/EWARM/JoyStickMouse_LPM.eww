<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\JoyStickMouse_LPM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>USB-Package-JoyStickMouse_LPM</name>
      <member>
        <project>JoyStickMouse_LPM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>JoyStickMouse_LPM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>JoyStickMouse_LPM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>JoyStickMouse_LPM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>JoyStickMouse_LPM</project>
        <configuration>STM32L152-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


