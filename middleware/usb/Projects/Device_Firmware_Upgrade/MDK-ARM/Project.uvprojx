# Keil uVision project Project.uvprojx, settings and files
target STM3210E-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F37x/CMSIS
    ./: startup_stm32f37x.s
    ../src/: system_stm32f37x.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_int.c usb_core.c usb_init.c usb_mem.c
  group STM32F10x/STM3210B_EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_spi_flash.c stm3210b_eval.c
  group User
    ../src/: dfu_mal.c flash_if.c usb_desc.c stm32_it.c usb_istr.c usb_pwr.c usb_prop.c hw_config.c main.c fsmc_nor.c nor_if.c spi_if.c
  group STM32L1xx/CMSIS
    ../src/: system_stm32l1xx.c
    ./: startup_stm32l1xx_md.s startup_stm32l1xx_hd.s
  group Doc
    ../: readme.txt
  group STM32F37x/STM32373C_EVAL
    ../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c
  group STM32F30x/STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_misc.c stm32f30x_gpio.c stm32f30x_exti.c stm32f30x_adc.c stm32f30x_rcc.c stm32f30x_pwr.c stm32f30x_flash.c stm32f30x_dma.c stm32f30x_syscfg.c stm32f30x_i2c.c stm32f30x_spi.c stm32f30x_usart.c
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_md.s startup_stm32f10x_xl.s startup_stm32f10x_hd.s
    ../src/: system_stm32f10x.c
  group STM32F30x/CMSIS
    ../src/: system_stm32f30x.c
    ./: startup_stm32f303xe.s startup_stm32f302x8.s startup_stm32f303xc.s
  group STM32L1xx/STM32L152_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_dma.c
  group STM32F37x/STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_exti.c stm32f37x_adc.c stm32f37x_misc.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_dma.c stm32f37x_pwr.c stm32f37x_i2c.c stm32f37x_spi.c stm32f37x_usart.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_exti.c stm32l1xx_syscfg.c stm32l1xx_flash.c stm32l1xx_gpio.c misc.c stm32l1xx_flash_ramfunc.c stm32l1xx_pwr.c stm32l1xx_usart.c stm32l1xx_rcc.c stm32l1xx_i2c.c stm32l1xx_dma.c stm32l1xx_spi.c stm32l1xx_sdio.c
  group STM32F30x/STM32303C_EVAL
    ../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group STM32F10x/STM3210E_EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_spi_flash.c
target STM3210B-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM3210E-EVAL_XL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL,USE_STM3210E_EVAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM32L152-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152VB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD,USE_STM32L152_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32L1xx/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32L1xx_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM32L152_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32L152D-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_HD,USE_STM32L152D_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32L1xx/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32L1xx_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM32L152D_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
target STM32373C_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F373VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F37X,USE_STM32373C_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F37x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F37x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM32373C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target STM32303C_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F30x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F30x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM32303C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
target STM32303xE_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303xE_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE,USE_STM32303C_EVAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
target STM32F032F302x8_Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F032F302x8_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8,USE_NUCLEO
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F30x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F30x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.3.0
